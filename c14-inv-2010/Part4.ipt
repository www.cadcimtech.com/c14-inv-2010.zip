# Autodesk Inventor part: Part4
## iProperties
Created: 2007-05
Part Number: Part4
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
