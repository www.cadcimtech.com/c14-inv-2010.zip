# Autodesk Inventor part: C13TUT4a.IPT2
## iProperties
Created: 2002-04
Part Number: C13TUT4a.IPT2
Document SubType Name: Modeling
## Feature names
1. Derived Body1 [Tagging]
