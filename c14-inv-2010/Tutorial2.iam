# Autodesk Inventor assembly: Tutorial2
## iProperties
Created: 2009-05
Part Number: Tutorial2
Document SubType Name: Assembly
Designer: Sham
Author: Sham
