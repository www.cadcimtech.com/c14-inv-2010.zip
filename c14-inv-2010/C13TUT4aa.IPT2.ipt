# Autodesk Inventor part: c13tut1
## iProperties
Created: 2002-04
Part Number: c13tut1
Material: Default
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Derived Body1 [Tagging]
