# Autodesk Inventor part: Tutorial3
## iProperties
Created: 2009-05
Part Number: Tutorial3
Document SubType Name: Modeling
Designer: Sham
Density: 1 g/cm^3
Author: Sham
## Feature names
1. Sweep1
